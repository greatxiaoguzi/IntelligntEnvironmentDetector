# Keil uVision project KEY.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEY +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   --bin -o  ..\OBJ\KEY.bin ..\OBJ\KEY.axf
  c flags: Optim=1 oTime=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\ADC;..\HARDWARE\EXTI;..\HARDWARE\INCLUDE;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\MOTO;..\HARDWARE\SYS_INIT;..\HARDWARE\SPI;..\HARDWARE\LCD;..\UCOSII\CONFIG;..\UCOSII\PORT;..\UCOSII\CORE;..\SYSTEM\delay;..\SYSTEM\usart;..\APP;..\HARDWARE\MYI2C;..\HARDWARE\SD_CARD;..\HARDWARE\ESP8266;..\HARDWARE\BMP_1820;..\HARDWARE\MYI2C;..\HARDWARE\EEPROM;..\HARDWARE\BSP;..\HARDWARE\W25Q64;..\HARDWARE\RS485;..\HARDWARE\AT24CXX;..\HARDWARE\RX8025T;..\HARDWARE\SHT30;..\HARDWARE\SenseAir_8_CO2;..\HARDWARE\LD3320;..\FATFS\option;..\FATFS;..\FONTSHOW;..\MALLOC;..\MAIN-UI;..\Algort
  library: MicroLIB
  memory RVCT4: ROM 0x800e000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SYS_INIT/: sys_init.c
    ../HARDWARE/MOTO/: Time3_pwm_init.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LCD/: ili93xx.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/SD_CARD/: sd.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/MYI2C/: myiic.c
    ../HARDWARE/BMP_1820/: bmp1820.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/W25Q64/: w25q64.c
    ../HARDWARE/RS485/: RS485.c
    ../HARDWARE/AT24CXX/: AT24cxx.c
    ../HARDWARE/RX8025T/: rx8025t.c
    ../HARDWARE/SHT30/: sht30.c
    ../HARDWARE/SenseAir_8_CO2/: senseair8.c
    ../HARDWARE/LD3320/: ld3320.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_flash.c misc.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOS-CONFIG
    ../UCOSII/CONFIG/: include.h os_cfg.h
  group UCOS-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group FATFS
    ../FATFS/: diskio.c ff.c Fat_API.c
    ../FATFS/option/: cc936.c
  group FONTSHOW
    ../FONTSHOW/: fontshow.c updatefont.c
  group APP
    ../APP/: APP.c
  group Algort
    ../Algort/: cjson.c
  group MALLOC
    ../MALLOC/: malloc.c
  group MAIN-UI
    ../MAIN-UI/: main-ui.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
